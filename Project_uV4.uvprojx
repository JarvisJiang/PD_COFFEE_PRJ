# Keil uVision project Project_uV4.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project_uV4 +hex
  c flags: Optim=1
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\app;.\app\Common;.\app\ESP8266;.\app\gpio;.\app\led;.\app\SysTick;.\app\Test;.\app\usart;.\app\CC2541;.\app\protocolToAPP;.\app\LinkMode;.\app\ds12;F:\NVT\NUC122BSP2016年3月7日11\NUC122BSP_CMSIS_v1.01.003\NuvotonPlatform_Keil\Sample\USB\RTCOPEN060415UA\user_Delay;.\app\uart_slave;.\app\heater_water;.\app\drv8801a;.\app\l9110_dc;.\app\gy_906;.\app\nfc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./app/: main.c stm32f10x_it.c ws_AT45DBXX.c ws_spi.c a4988_driver.c rfm69.c actol_db.c actol_rfm69.c at25512.c
  group STM32F10x_StdPeriph_Lib_V3.5.0
    ./app/: actol_bluetooth.c
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dac.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_tim.c misc.c
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd_vl.s
  group User
    ./app/Common/: Common.c
    ./app/ESP8266/: bsp_esp8266.c
    ./app/led/: bsp_led.c
    ./app/SysTick/: bsp_SysTick.c
    ./app/Test/: test.c
    ./app/usart/: bsp_usart1.c
    ./app/CC2541/: cc2541.c
    ./app/uart_slave/: uart_slave.c
    ./app/heater_water/: water_heater.c water_heater_pid.c
    ./app/drv8801a/: drv8810a.c
    ./app/l9110_dc/: l9110_dc.c
    ./app/gy_906/: gpio_gy906.c gy906.c gy906_iic.c
  group protocolAPP
    ./app/protocolToAPP/: protocolToAPP.c
  group ADS12
    ./app/ds12/: DS_delay.c ADS1220.C
    ./app/pt100/: PT100.c
  group NFC
    ./app/nfc/: nfc_process.c rc522.c rc522_iic.c
software components: CMSIS:CORE 4.3.0
